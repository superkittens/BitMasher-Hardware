# Repository superkittens/BitMasher-Hardware

File README.md:

# BitMasher Hardware Design Files

Schematics and PCB design files for BitMasher.

## Licensing
BitMasher design files are under the Creative Commons Attribution-ShareAlike 3.0 License [CC BY-SA 3.0](https://creativecommons.org/licenses/by-sa/3.0/legalcode)

> **Important**: BitMasher is under continuous development.  Its code and design is subject to frequent changes.  No guarantees are made about its safety and performance.  When working with audio systems, it is important to make the necessary precautions to protect your hearing.  Use the BitMasher code and design files at your own risk!

## KiCad design BitMasher/BitMasher.kicad_pcb

Parts:
C1: 10n; C_0402_1005Metric
C2, C4, C8: 10u; C_0402_1005Metric
C3: 4.7u; C_0402_1005Metric
C5: 470p; C_0402_1005Metric
C6: 0.22u; C_0402_1005Metric
C7: 2.2u; C_0402_1005Metric
D1: IP4220CZ6; SOT-457; Digikey PN 1727-3578-1-ND
D2: DESDALC5LP-7B; D_0402_1005Metric
D3: LED; LED_0603_1608Metric; Digikey PN 754-1790-1-ND
D4: LED; LED_0603_1608Metric
F1, F2: 0603L050YR; Fuse_0603_1608Metric; Digikey PN F4150CT-ND
J1: USB_B_Micro; USB_Micro-B_Amphenol_10118194_Horizontal; Digikey PN 609-4618-1-ND
J2: EXT_PWR; PinHeader_1x02_P2.54mm_Vertical
J3: AAA Cell Mount; BatteryHolder_Keystone_55; Mouser PN 534-055
J4, J5, J6: AAA Cell Mount; BatteryHolder_Keystone_55
L1: BKP1005TS330-T; L_0402_1005Metric; Digikey PN 587-3015-1-ND
R1: 16.8k; R_0402_1005Metric
R2, R3: 3k; R_0402_1005Metric
TP1, TP2: TestPoint; TestPoint_Pad_D2.0mm
TP3, TP4: TestPoint_Probe; TestPoint_Plated_Hole_D2.0mm
TP5: TestPoint_Probe; TestPoint_Pad_D2.0mm
U1: LTC4413; DFN-10-1EP_3x3mm_P0.5mm_EP1.65x2.38mm
U2: MIC5219-2.5YM5; SOT-23-5; Digikey PN MIC5219-2.5YM5-TR
U3: REG710NA; TSOT-23-6; Digikey PN 296-12136-1-ND

Connections:
3V0_EN: R1.1, U3.3 (EN); also elsewhere on the board
+2V5: C7.1, D3.2 (A), TP3.1, U2.5 (OUT); also elsewhere on the board
+3V0: C8.1, D4.2 (A), TP4.1, U3.1 (VOUT); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, D1.2, D2.2 (A2), J1.5 (GND), J1.6 (Shield), J2.2, J6.1, R1.2, R2.2, R3.2, TP5.1, U1.2 (ENBA), U1.3 (GND), U1.4 (ENBB), U1.11, U2.2 (GND), U3.2 (GND); also elsewhere on the board
unnamed: C1.1, F1.1, L1.1
unnamed: C3.1, C4.1, U1.6 (OUTB), U1.10 (OUTA), U2.1 (IN), U2.3 (EN), U3.5 (VIN)
unnamed: C5.1, U2.4 (BP)
unnamed: C6.1, U3.6 (C+)
unnamed: C6.2, U3.4 (C-)
unnamed: D1.5, F1.2, J1.1 (VBUS)
unnamed: D2.1 (A1), F2.2, J2.1, J3.1
unnamed: D3.1 (K), R2.1
unnamed: D4.1 (K), R3.1
unnamed: F2.1, U1.1 (INA)
unnamed: J4.1, J5.1
USB_DN: D1.6, J1.2 (D-), TP2.1; also elsewhere on the board
USB_DP: D1.1, J1.3 (D+), TP1.1; also elsewhere on the board
VBUS: C2.1, L1.2, U1.5 (INB); also elsewhere on the board

Notes on the sheet:
(-)
(+)
Power Test Points
2x AAA Cell

Parts:
C9: 100n; C_0402_1005Metric
C10, C14, C15: 10u; C_0402_1005Metric
C11: 0.01u; C_0402_1005Metric
C12, C22: 1u; C_0402_1005Metric
C13, C16, C17, C18, C19, C20, C21: 0.1u; C_0402_1005Metric
D5: IND; LED_0603_1608Metric; Digikey PN 1497-1167-1-ND
DISP1: LS013B7DH03; Hirose_FH12-10S-0.5SH_1x10-1MP_P0.50mm_Horizontal; Digikey PN HFK110CT-ND
R4: 100; R_0402_1005Metric
R5: 4.7k; R_0402_1005Metric
R6: 4k; R_0402_1005Metric
R7: 10M; R_0402_1005Metric
R8: 3k; R_0402_1005Metric
SW1: BOOT; SW_DPDT_JS202011SCQN; Mouser PN 611-JS202011SCQN
SW10: RESET; SW_Push_1P1T_NO_CK_KMR2; Digikey PN 401-1426-1-ND
SW11: BOOT; SW_Push_1P1T_NO_CK_KMR2; Digikey PN 401-1426-1-ND
TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17: TestPoint; TestPoint_Pad_D2.0mm
U4: EFM32PG12B500F1024GM48; QFN-48-1EP_7x7mm_P0.5mm_EP5.3x5.3mm
U5: 74AVCH4T245RSVR-NT; 16-XQFN
Y1: 40 MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm; Mouser PN 581-CX2016DB40DFLJCC; Digikey PN 1253-1120-1-ND
Y2: 32.768 kHz; Crystal_SMD_MicroCrystal_CM9V-T1A-2Pin_1.6x1.0mm; Digikey PN 728-1129-1-ND

Connections:
3V0_EN: U4.17 (PD8); also elsewhere on the board
+2V5: C10.1, C11.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, R5.1, R6.1, R8.1, U4.9 (AVDD), U4.34 (AVDD), U4.39 (VREGVDD), U4.40 (DVDD), U4.42 (IOVDD), U5.3 (VCCA), U5.4 (1DIR), U5.5 (2DIR); also elsewhere on the board
+3V0: C19.1, C20.1, C21.1, C22.1, DISP1.3 (EXTMODE), DISP1.4 (VDD), DISP1.5 (VDDA), DISP1.6 (DISP), R7.1, U5.2 (VCCB); also elsewhere on the board
/Microcontroller/Display/APP_RX: SW1.4 (A), U4.26 (PA1)
/Microcontroller/Display/APP_TX: SW1.1 (A), U4.25 (PA0)
/Microcontroller/Display/DEBUG_CH0: TP14.1, U4.44 (PC7)
/Microcontroller/Display/DEBUG_CH1: TP15.1, U4.46 (PC9)
/Microcontroller/Display/DEBUG_CH2: TP16.1, U4.47 (PC10)
/Microcontroller/Display/DEBUG_CH3: TP17.1, U4.48 (PC11)
/Microcontroller/Display/DISP_COM_HV: DISP1.7 (EXTCOMIN), TP12.1, U5.13 (2B1)
/Microcontroller/Display/DISP_COM_LV: TP7.1, U4.22 (PD13), U5.8 (2A1)
/Microcontroller/Display/DISP_CS_HV: DISP1.8 (SCS), TP13.1, U5.12 (2B2)
/Microcontroller/Display/DISP_CS_LV: TP6.1, U4.23 (PD14), U5.9 (2A2)
/Microcontroller/Display/DISP_MOSI_HV: DISP1.9 (SI), TP10.1, U5.15 (1B1)
/Microcontroller/Display/DISP_MOSI_LV: TP9.1, U4.43 (PC6), U5.6 (1A1)
/Microcontroller/Display/DISP_OE: R5.2, U4.3 (PF2), U5.1 (1~OE), U5.16 (2~OE)
/Microcontroller/Display/DISP_SCK_HV: DISP1.10 (SCLK), TP11.1, U5.14 (1B2)
/Microcontroller/Display/DISP_SCK_LV: TP8.1, U4.45 (PC8), U5.7 (1A2)
/Microcontroller/Display/LED_IND: D5.1 (K), U4.4 (PF3)
BUTT0: U4.27 (PA2); also elsewhere on the board
BUTT1: U4.28 (PA3); also elsewhere on the board
BUTT2: U4.29 (PA4); also elsewhere on the board
BUTT3: U4.30 (PA5); also elsewhere on the board
BUTT4: U4.5 (PF4); also elsewhere on the board
BUTT5: U4.6 (PF5); also elsewhere on the board
BUTT6: U4.7 (PF6); also elsewhere on the board
BUTT7: U4.8 (PF7); also elsewhere on the board
CODEC0: U4.20 (PD11); also elsewhere on the board
CODEC1: U4.19 (PD10); also elsewhere on the board
CODEC2: U4.24 (PD15); also elsewhere on the board
CODEC3: U4.21 (PD12); also elsewhere on the board
CODEC4: U4.18 (PD9); also elsewhere on the board
CODEC5: U4.31 (PB11); also elsewhere on the board
CODEC6: U4.32 (PB12); also elsewhere on the board
CODEC7: U4.33 (PB13); also elsewhere on the board
GND: C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, DISP1.1 (VSSA), DISP1.2 (VSS), R4.2, R7.2, U4.37 (VREGVSS), U4.49 (VSS), U5.10 (GND), U5.11 (GND), Y1.2, Y1.4; also elsewhere on the board
HOST0: SW1.2 (B); also elsewhere on the board
HOST1: SW1.5 (B); also elsewhere on the board
MCU_RESET: C9.1, SW10.2, U4.12 (RESETn); also elsewhere on the board
unnamed: C12.1, U4.41 (DECOUPLE)
unnamed: D5.2 (A), R8.2
unnamed: R4.1, SW10.1
unnamed: R6.2, SW11.2
unnamed: U4.10 (HFXTAL_N), Y1.1
unnamed: U4.11 (HFXTAL_P), Y1.3
unnamed: U4.35 (PB14), Y2.2
unnamed: U4.36 (PB15), Y2.1
SWD_SWCLK: SW1.3 (C), SW11.1, U4.1 (PF0); also elsewhere on the board
SWD_SWDIO: SW1.6 (C), U4.2 (PF1); also elsewhere on the board

Notes on the sheet:
DOWN
SDOUT
CODEC_SCL
Display Connections
SDIN
START
HOST_RX
CODEC_RST
HOST_TX
CODEC_MCLK
Display Level Shifting / Debug Breakout
CODEC_LRCK
RIGHT
CODEC_SDA
CODEC_CLK
Microcontroller IO Connections
LEFT
Microcontroller Power
SEL

Parts:
C50, C51: 47p; C_0402_1005Metric
C52: 4.7u; C_0402_1005Metric
C53, C54: 100n; C_0402_1005Metric
D11: DESDALC5LP-7B; D_0402_1005Metric; Digikey PN DESDALC5LP-7BDICT-ND
D12, D13, D14, D15, D16, D17, D18: DESDALC5LP-7B; D_0402_1005Metric
D19: LED; LED_0603_1608Metric
Q1, Q2: Q_NMOS_GSD; SOT-23; Digikey PN NTR4501NT1GOSCT-ND
R27, R28: 27; R_0402_1005Metric
R29: 3k; R_0402_1005Metric
R30, R31, R32, R33: 4.7k; R_0402_1005Metric
SW2: UP; LL3301NF065QG
SW3: DOWN; LL3301NF065QG
SW4: LEFT; LL3301NF065QG
SW5: RIGHT; LL3301NF065QG
SW6: A; LL3301NF065QG
SW7: B; LL3301NF065QG
SW8: START; LL3301NF065QG
SW9: SEL; LL3301NF065QG
U7: FT230XQ; QFN-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm; Digikey PN 768-1130-1-ND

Connections:
+2V5: R31.2, R33.2; also elsewhere on the board
+3V3: C53.2, Q1.1 (G), Q2.1 (G), R30.2, R32.2, U7.1 (VCCIO), U7.8 (3V3OUT), U7.9 (~RESET)
BUTT0: D11.1 (A1), SW2.4 (A); also elsewhere on the board
BUTT1: D12.1 (A1), SW3.4 (A); also elsewhere on the board
BUTT2: D13.1 (A1), SW4.4 (A); also elsewhere on the board
BUTT3: D14.1 (A1), SW5.4 (A); also elsewhere on the board
BUTT4: D15.1 (A1), SW6.4 (A); also elsewhere on the board
BUTT5: D16.1 (A1), SW7.4 (A); also elsewhere on the board
BUTT6: D17.1 (A1), SW8.4 (A); also elsewhere on the board
BUTT7: D18.1 (A1), SW9.4 (A); also elsewhere on the board
GND: C50.2, C51.2, C52.2, C53.1, C54.2, D11.2 (A2), D12.2 (A2), D13.2 (A2), D14.2 (A2), D15.2 (A2), D16.2 (A2), D17.2 (A2), D18.2 (A2), R29.2, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, SW9.1, U7.3 (GND), U7.13 (GND), U7.17 (GND); also elsewhere on the board
HOST0: Q2.3 (D), R33.1; also elsewhere on the board
HOST1: Q1.3 (D), R31.1; also elsewhere on the board
unnamed: D19.1 (K), R29.1
unnamed: Q1.2 (S), R30.1, U7.15 (TXD)
unnamed: Q2.2 (S), R32.1, U7.2 (RXD)
unnamed: R27.1, U7.7 (USBDM)
unnamed: R28.2, U7.6 (USBDP)
USB_DN: C50.1, R27.2; also elsewhere on the board
USB_DP: C51.1, R28.1; also elsewhere on the board
VBUS: C52.1, C54.1, D19.2 (A), U7.10 (VCC); also elsewhere on the board

Parts:
D20: SP0505BAHT; SOT-23-6
J9: Conn_02x10_Odd_Even; PinHeader_2x10_P1.27mm_Vertical_SMD; Digikey PN SAM12603-ND
TP23, TP24, TP25, TP26, TP27: TestPoint; TestPoint_Pad_D2.0mm

Connections:
+2V5: J9.1; also elsewhere on the board
GND: D20.2 (A), J9.3, J9.5, J9.9, J9.15, J9.17, J9.19; also elsewhere on the board
MCU_RESET: D20.6 (K), J9.10, TP27.1; also elsewhere on the board
unnamed: D20.5 (K), J9.8, TP26.1
SWD_SWCLK: D20.3 (K), J9.4, TP24.1; also elsewhere on the board
SWD_SWDIO: D20.1 (K), J9.2, TP23.1; also elsewhere on the board
SWD_SWO: D20.4 (K), J9.6, TP25.1

Parts:
C23: 10u; C_0402_1005Metric
C24, C26, C35, C37, C43: 0.1u; C_0402_1005Metric
C25, C28, C33, C42: 0.01u; C_0402_1005Metric
C27, C29, C30, C32, C34: 47p; C_0402_1005Metric
C31, C36, C39, C41, C48, C49: 1u; C_0402_1005Metric
C38, C40: 0.022u; C_0402_1005Metric
C44, C45, C46, C47: 150p; C_0402_1005Metric
D6, D7, D8, D9, D10: DESD3V3S1BL-7B; D_0402_1005Metric
J7, J8: SJ2-35863B1-SMT; SJ2-35863B1-SMT-TR
L3, L4, L5, L6, L7, L8: 1.5k @ 100MHz; L_0402_1005Metric; Digikey PN 587-3216-1-ND
L9: 1.5k @ 100MHz; L_0402_1005Metric
R9, R10: 6.49k; R_0402_1005Metric
R11, R12, R13, R14, R15, R16, R17, R23: 22.1; R_0402_1005Metric
R18, R19: 51.1; R_0402_1005Metric
R20: 4.7k; R_0402_1005Metric
R21, R22: 2k; R_0402_1005Metric
R24, R25: 8.06k; R_0402_1005Metric
R26: 47.5k; R_0402_1005Metric
U6: CS42L52; QFN-40-1EP_6x6mm_P0.5mm_EP4.1x4.1mm

Connections:
+2V5: C23.1, C24.1, C25.1, C26.1, C28.1, C33.1, C35.1, C37.1, C42.1, C43.1, R9.1, R10.1, R26.1, U6.5 (VP), U6.8 (VP), U6.13 (+VHP), U6.16 (VA), U6.33 (VL), U6.34 (VD); also elsewhere on the board
/Audio Codec/HP_DETECT: R23.2, U6.31 (SPKR/HP)
CODEC0: C32.1, R14.1; also elsewhere on the board
CODEC1: C27.1, R17.1; also elsewhere on the board
CODEC2: C30.1, R15.1; also elsewhere on the board
CODEC3: C34.1, R13.2; also elsewhere on the board
CODEC4: C29.1, R16.1; also elsewhere on the board
CODEC5: R9.2, R12.2; also elsewhere on the board
CODEC6: R10.2, R11.2; also elsewhere on the board
CODEC7: R20.2, U6.32 (RESET); also elsewhere on the board
GND: C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C37.2, C39.1, C41.2, C42.2, C43.2, C44.1, C45.2, C46.1, C47.2, D6.2 (A2), D7.2 (A2), D8.2 (A2), D9.2 (A2), D10.2 (A2), L8.1, L9.2, R18.1, R19.2, R20.1, R21.1, R22.2, U6.3 (AD0), U6.17 (AGND), U6.35 (DGND), U6.41 (GND); also elsewhere on the board
unnamed: C31.1, U6.10 (-VHPFILT)
unnamed: C36.1, U6.12 (FLYP)
unnamed: C36.2, U6.11 (FLYN)
unnamed: C38.1, R18.2
unnamed: C38.2, L3.1, U6.15 (HP/LINE_OUTA)
unnamed: C39.2, U6.18 (FILT+)
unnamed: C40.1, L4.1, U6.14 (HP/LINE_OUTB)
unnamed: C40.2, R19.1
unnamed: C41.1, U6.19 (VQ)
unnamed: C44.2, U6.27 (AFILTA)
unnamed: C45.1, U6.28 (AFILTB)
unnamed: C46.2, C48.1, U6.30 (AIN1B)
unnamed: C47.1, C49.2, U6.29 (AIN1A)
unnamed: C48.2, R21.2, R24.2
unnamed: C49.1, R22.1, R25.2
unnamed: D6.1 (A1), J8.2, L3.2
unnamed: D7.1 (A1), J8.3, L4.2
unnamed: D8.1 (A1), J8.4, L7.2
unnamed: D9.1 (A1), J7.2, L6.2
unnamed: D10.1 (A1), J7.3, L5.2
unnamed: J7.1, L9.1
unnamed: J8.1, L8.2
unnamed: L5.1, R24.1
unnamed: L6.1, R25.1
unnamed: L7.1, R23.1, R26.2
unnamed: R11.1, U6.1 (SDA)
unnamed: R12.1, U6.2 (SCL)
unnamed: R13.1, U6.40 (LRCK)
unnamed: R14.2, U6.39 (SDIN)
unnamed: R15.2, U6.38 (SCLK)
unnamed: R16.2, U6.37 (MCLK)
unnamed: R17.2, U6.36 (SDOUT)

Notes on the sheet:
Line In
Headphone/Line Out

Board: 2 copper layers, 60.0 x 100.0 mm, 171 parts (6 on the bottom side), 104 nets.

## Commit log

2022-02-25 Add readme
